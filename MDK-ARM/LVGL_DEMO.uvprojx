# Keil uVision project LVGL_DEMO.uvprojx, settings and files
target LVGL_DEMO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: LVGL_DEMO +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../st7789_driver/inc;../LVGL/GUI;../LVGL/GUI/lvgl;../LVGL/GUI/lvgl/src;../LVGL/GUI/lvgl/examples/porting;../LVGL/GUI_APP/demos;../LVGL/GUI_APP/demos/keypad_encoder;../LVGL/GUI_APP/demos/stress;../LVGL/GUI_APP/demos/widgets;../LVGL/GUI_APP/demos/widgets/assets;../LVGL/GUI_APP/demos/benchmark/assets;../LVGL/GUI_APP/demos/benchmark;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Touch
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: getopt.c shell.c wire.c delayus.c main.c gpio.c freertos.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group st7789
    ../st7789_driver/src/: driver_st7789.c driver_st7789_basic.c driver_st7789_display_test.c stm32f411_driver_st7789_interface.c
  group Middlewares/lvgl/example/porting
    ../LVGL/GUI/lvgl/examples/porting/: lv_port_disp_template.c
  group Middlewares/lvgl/src/core
    ../LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Middlewares/lvgl/src/draw
    ../LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group Middlewares/lvgl/src/font
    ../LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Middlewares/lvgl/src/hal
    ../LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Middlewares/lvgl/src/misc
    ../LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Middlewares/lvgl/src/widgets
    ../LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Middlewares/lvgl/src/extra
    ../LVGL/GUI/lvgl/src/extra/: lv_extra.c
    ../LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../LVGL/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../LVGL/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../LVGL/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../LVGL/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../LVGL/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../LVGL/GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../LVGL/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../LVGL/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../LVGL/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
  group Middlewares/LVGL/GUI_APP
    ../LVGL/GUI_APP/demos/stress/: lv_demo_stress.c
    ../LVGL/GUI_APP/demos/keypad_encoder/: lv_demo_keypad_encoder.c
    ../LVGL/GUI_APP/demos/widgets/: lv_demo_widgets.c
    ../LVGL/GUI_APP/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
    ../LVGL/GUI_APP/demos/benchmark/: lv_demo_benchmark.c
    ../LVGL/GUI_APP/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Touch
    ../Touch/: touch.c
software components: CMSIS:CORE 4.3.0
